# Keil uVision project adc_uart.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: APM32F103ZE Geehy
  pack: Geehy.APM32F1xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: adc_uart +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c adc1282.c ADS1282.h tim_adc.c tim_adc.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 1.0.2, Device:StdPeriph Drivers:EINT 1.0.2, Device:StdPeriph Drivers:Framework 1.0.2, Device:StdPeriph Drivers:GPIO 1.0.2, Device:StdPeriph Drivers:RCM 1.0.2, Device:StdPeriph Drivers:SPI 1.0.2, Device:StdPeriph Drivers:TMR 1.0.2, Device:StdPeriph Drivers:USART 1.0.2
